# Keil uVision project GJH_slave.uvprojx, settings and files
target GJH_slave (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GJH_slave
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\USER\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/src/: JY901.c mian.c thread_mw.c usart1.c usart2.c usart3.c xnumx.c hx711.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0, RTOS:kernel 3.1.2
