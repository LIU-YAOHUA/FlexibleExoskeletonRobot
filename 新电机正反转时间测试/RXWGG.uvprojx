# Keil uVision project RXWGG.uvprojx, settings and files
target RXWGG (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: RXWGG
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\USER\inc;.\USER\USMART
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group USER
    ./USER/src/: main.c control.c
  group ZDYZ
    ./USER/src/: delay.c sys.c usart.c timer.c adc.c
  group MWF7
    ./USER/src/: exti.c usart2.c usart3.c pwm.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.2.2
